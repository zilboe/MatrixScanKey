# Keil uVision project key_scan.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: key_scan +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\key_scan;.\Key;.\usart;.\Timer;.\Application
  group Application
    ./Application/: main.c
  group Key
    ./Key/: Key.c
  group usart
    ./usart/: usart.c
  group Timer
    ./Timer/: Timer.c
